Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-12T13:52:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 12 13:52:32 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{E585C798-6D92-4071-A08F-012786E300FB}\ifc * Database version: 5507 * Database creation date: Wed Jun 12 13:52:31 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 12 13:52:32 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 12 13:52:32 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1832FG Kitchen faucet, 1832FG(2018):1832FG Kitchen faucet:335299
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 278.753 mm; NominalHeight: 215.58 mm; NominalWidth: 54.5498 mm; Projection: 231 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1832FG(2018); ConvergoRefNr: 0087-1906-0040-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 11/06/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150089589; EN Standard: EN 817; LVI Number: 6219155; Noise Class: I (ISO 3822); NRF Number: 4200447; RSK Number: 8310968
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1832FG; Catalog Drawing URL: http://static.oras.com/catdrw/1832FG; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1832FG; FDV Document URL: http://www.oras.com/datasheet/1832FG/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1832FG; Group: Kitchen faucets; Long Marketing: Kitchen faucet with pull-out spout. Swivel spout with pull-out spout/spray and aerator. Spout’s pull-out length can be fixed. Spout’s swing angle is factory preset at 120° (can be limited to 40°-80°). Lever is equipped with an eco-button for limiting flow-rate, which can be bypassed by pressing the button. With flexible pipes.; Manufacturer: Oras; Market: INT;FIN;SWE;POL;EST;LTU;LVA;UKR; Model: 1832FG Kitchen faucet; Name_en: 1832FG Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 754 x 334 x 63; Package Weight: 2.7 kg; Product Code: 1832FG; Product Datasheet: http://www.oras.com/datasheet/1832FG/en; Product Family: Oras Vega; Product Image URL: http://static.oras.com/image/1832FG; Product URL: http://static.oras.com/1832FG; Type Name: 1832FG Kitchen faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G3/8; Eco Flow At 300kPa: 0.00247203 m3/s; Flow Rate At 300kPa: 0.00565035 m3/s; Installation and Maintenance: http://static.oras.com/manual/1832FG; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 01ls: 90000 Pa; Spare Parts: http://static.oras.com/sp/1832FG; Spout Type: Swivel spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1832FG(2018); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1832FG; Name: 1832FG Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 55x280x215 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1832FG; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1832FG Kitchen faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0881588 m2; Volume: 0.0032828 m3
Identity Data - Mark: 8
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1832FG(2018): 1832FG Kitchen faucet; Family and Type: 1832FG(2018): 1832FG Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1832FG(2018): 1832FG Kitchen faucet; Type Id: 1832FG(2018): 1832FG Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
